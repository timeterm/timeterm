DISABLE_OVERSCAN = "1"
RPI_EXTRA_CONFIG = "max_usb_current=1 \n\
hdmi_group=2 \n\
hdmi_mode=87 \n\
hdmi_cvt 1280 800 60 6 0 0 0\n\
hdmi_drive=1"

