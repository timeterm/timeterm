FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

MACHINE_HOSTNAME = "timeterm"

