RDEPENDS_${PN}_remove = "qdb"

