FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

CMDLINE_append = " quiet splash logo.nologo loglevel=1 consoleblank=0 "

